# Keil uVision project bl_core.uvprojx, settings and files
target nRF51422_xxAC (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bl_core (library)
  c flags: Optim=1 wLevel=2
  c define: NRF51 APP_ERROR_H__
  c misc: --c99
  c include: ..\include;..\..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\..\components\libraries\util
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20007000 size 0x1000
  group core
    ../: bootloader_app_bridge.c bootloader_info.c bootloader_mesh.c dfu_mesh.c uECC.c
  group lib
    ../../../../../../components/libraries/sha256/: sha256.c
