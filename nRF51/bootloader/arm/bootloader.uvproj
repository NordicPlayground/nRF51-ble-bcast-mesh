# Keil uVision project bootloader.uvproj, settings and files
target nRF51422 xxAC serial (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader_serial_xxAC +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51 BOARD_PCA10028 BOOTLOADER SERIAL RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1 uECC_PLATFORM=uECC_arm
  c misc: --c99 --debug
  c include: ..\..\rbc_mesh\include;..\..\RTT;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\toolchain\gcc;..\..\..\..\SDK\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\rbc_mesh;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\include;..\..\..\..\..\components\device;..\..\..\..\..\components\libraries\sha256;..\..\SDK\bsp;..\core\include
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
  link misc: --diag-suppress 6314
  group app
    ../: main.c transport.c bootloader.c bootloader_rtc.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../components/libraries/sha256/: sha256.c
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group rbc_mesh
    ../../rbc_mesh/src/: bootloader_util.c fifo.c mesh_aci.c mesh_packet.c nrf_flash.c radio_control.c rand.c serial_handler_uart.c
  group shared
    ../core/: bootloader_app_bridge.c bootloader_info.c uECC.c dfu_mesh.c dfu_transfer_mesh.c dfu_bank.c
    ../../rbc_mesh/src/: dfu_util.c
target nRF51422 xxAC serial debug (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_serial_debug_xxAC +hex
  c flags: Optim=1 wLevel=2
  c define: RTT_LOG DEBUG NRF51 BOARD_PCA10028 BOOTLOADER SERIAL RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1 uECC_PLATFORM=uECC_arm
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x36000 size 0x9800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAC (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_xxAC +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51 BOARD_PCA10028 BOOTLOADER RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAA serial (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_serial_xxAA +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAA (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_xxAA +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAB serial (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_serial_xxAB +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAB (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader_xxAB +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
