# Keil uVision project bootloader.uvproj, settings and files
target nRF51422 xxAA (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader
  c flags: Optim=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\rbc_mesh\include;..\..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\..\components\libraries\bootloader_dfu
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../../../rbc_mesh/src/: bootloader.c nrf_flash.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../../../components/libraries/bootloader_dfu/: bootloader_util.c
