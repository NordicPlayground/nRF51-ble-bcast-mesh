# Keil uVision project bootloader.uvprojx, settings and files
target nRF51422 xxAA (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 BOARD_PCA10028 BOOTLOADER
  c misc: --c99
  c include: ..\..\..\..\rbc_mesh\include;..\..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\SDK\bsp;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\rbc_mesh;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\fifo;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x6000
  group app
    ../: bootloader_timeslot.c main.c journal.c records.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../../../components/libraries/bootloader_dfu/: bootloader_util.c
    ../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
  group rbc_mesh
    ../../../../rbc_mesh/src/: dfu.c event_handler.c fifo.c mesh_aci.c mesh_packet.c nrf_flash.c radio_control.c version_handler.c rbc_mesh.c serial_handler.c timer_control.c transport_control.c trickle.c bootloader.c
