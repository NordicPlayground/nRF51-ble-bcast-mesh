# Keil uVision project rbc_mesh_dfu_example.uvproj, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: rbc_mesh_scaling +hex
  c flags: Optim=1 wLevel=2
  c define: RBC_MESH_GATTS_ATTR_TABLE_SIZE=0x4100 BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\RTT;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\libraries\fifo
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ../: main.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c mesh_srv.c radio_control.c timer_control.c timeslot_handler.c transport_control.c trickle.c mesh_aci.c serial_handler.c fifo.c event_handler.c mesh_packet.c version_handler.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
