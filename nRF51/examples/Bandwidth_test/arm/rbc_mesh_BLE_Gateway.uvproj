# Keil uVision project rbc_mesh_BLE_Gateway.uvproj, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: rbc_gateway_example +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT __WEAK=__weak DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\device
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../: main.c nrf_adv_conn.c led_config.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c nrf_flash.c mesh_flash.c radio_control.c timer.c timeslot.c trickle.c mesh_gatt.c transport_control.c mesh_aci.c serial_handler_uart.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_util.c rand.c handle_storage.c timer_scheduler.c dfu_app.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    ../../../../../../components/ble/common/: ble_advdata.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target nRF51822 xxAA serial (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: rbc_gateway_example_serial +hex
  c flags: Optim=1 wLevel=2
  c define: MESH_DFU RTT_LOG DEBUG BUTTONS BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL RBC_MESH_DATA_CACHE_ENTRIES=2 RBC_MESH_HANDLE_CACHE_ENTRIES=3 __WEAK=__weak
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x5000
  memory RVCT10: RAM 0x20007000 size 0xffc
target nRF51822 xxAA buttons (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: rbc_gateway_example +hex
  c flags: Optim=1 wLevel=2
  c define: RBC_MESH_DEBUG DEBUG_LOG_RTT BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BUTTONS DEBUG __WEAK=__weak
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20002000 size 0x6000
