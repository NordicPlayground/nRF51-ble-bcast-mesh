# Keil uVision project rbc_mesh_scaling_example.uvprojx, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_mesh_scaling +hex
  c flags: Optim=1 wLevel=2
  c define: RBC_MESH_GATTS_ATTR_TABLE_SIZE=0x4100 BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\RTT;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\libraries\fifo
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../: main.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c transport_control.c fifo.c event_handler.c handle_storage.c version_handler.c mesh_packet.c mesh_gatt.c bootloader_app.c bootloader_info_app.c bootloader_util.c rand.c
  group core
    ./: system_nrf51.c arm_startup_nrf51.s
  group lib
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
