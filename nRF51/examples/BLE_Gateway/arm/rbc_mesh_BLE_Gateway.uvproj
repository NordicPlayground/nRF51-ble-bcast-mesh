# Keil uVision project rbc_mesh_BLE_Gateway.uvproj, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: rbc_mesh_BLE_Gateway +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT __WEAK=__weak
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group app
    ../: led_config.c main.c nrf_adv_conn.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c mesh_srv.c timer_control.c radio_control.c timeslot_handler.c transport_control.c trickle.c mesh_aci.c serial_handler.c fifo.c event_handler.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/ble/common/: ble_advdata.c
target nRF51822 xxAA serial (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: rbc_mesh_BLE_Gateway +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL __WEAK=__weak
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20003000 size 0x5000
target nRF51822 xxAA buttons (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: rbc_mesh_BLE_Gateway +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BUTTONS __WEAK=__weak
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20003000 size 0x5000
