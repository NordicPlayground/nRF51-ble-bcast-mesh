# Keil uVision project rbc_mesh_BLE_Gateway.uvprojx, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_gateway_example +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: BOARD_PCA10001 NRF51
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\..\..\SDK\nrf51822\Include;..\..\..\..\..\SDK\nrf51822\Include\ble;..\..\..\..\..\SDK\nrf51822\Include\ble\ble_services;..\..\..\..\..\SDK\nrf51822\Include\sd_common;..\..\..\..\..\SDK\nrf51822\Include\s110;..\..\..\..\..\SDK\nrf51822\Include\app_common;..\..\..\..\..\SDK\nrf51822\Include\gcc
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ../: main.c nrf_adv_conn.c led_config.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c mesh_srv.c transport_control.c
  group core
    ../../../../../SDK/nrf51822/Source/templates/: system_nrf51.c
    ../../../../../SDK/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../../../SDK/nrf51822/Source/ble/: ble_advdata.c
    ../../../../../SDK/nrf51822/Source/nrf_delay/: nrf_delay.c
    ../../../../../SDK/nrf51822/Source/simple_uart/: simple_uart.c
