# Keil uVision project Trickle.uvproj, settings and files
target PCA10003 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Trickle_10003 +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_PCA10003 NRF51
  c include: ..\..\Trickle;..\..\..\SDK\nrf51822\Include;..\..\..\SDK\nrf51822\Include\app_common;..\..\..\SDK\nrf51822\Include\s110;..\..\..\SDK\nrf51822\Include\sd_common;..\..\..\SDK\nrf51822\Include\ble;..\..\..\SDK\nrf51822\Include\ble\ble_services
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group core
    ./: arm_startup_nrf51.s
    ../../../SDK/nrf51822/Source/templates/: system_nrf51.c
  group app
    ../: radio_control.c trickle.c rebroadcast.c ll_control.c nrf_adv_conn.c rbc_database.c test_application.c timer_control.c timeslot_handler.c
  group lib
    ../../../SDK/nrf51822/Source/nrf_delay/: nrf_delay.c
    ../../../SDK/nrf51822/Source/simple_uart/: simple_uart.c
    ../../../SDK/nrf51822/Source/ble/: ble_advdata.c
target PCA10000 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: Trickle_10000 +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_PCA10000 NRF51
  c include: ..\..\Trickle;..\..\..\SDK\nrf51822\Include;..\..\..\SDK\nrf51822\Include\app_common;..\..\..\SDK\nrf51822\Include\sd_common;..\..\..\SDK\nrf51822\Include\s110
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
